DTB_SUBDIR="dts/"

require recipes-kernel/linux/linux-altera-ltsi.inc
SRC_URI[md5sum] = "4e00123eae5088baf0c399b91ff53288"
SRC_URI[sha256sum] = "00cd02d18417aac94b17ed31d3f75d823afc1fba32e310932f37048cb5f39b50"

